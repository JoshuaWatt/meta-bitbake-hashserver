require bitbake-hashserver-container-image.inc
